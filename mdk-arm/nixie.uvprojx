# Keil uVision project nixie.uvprojx, settings and files
target nixie-clock (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F051K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nixie
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F051x8, USE_HAL_DRIVER
  c include: ..\inc;..\lib\stm32f0xx-hal-lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../src/: system_stm32f0xx.c startup_stm32f051x8.s
  group src
    ../src/: button.c shift_reg.c nixie.c stm32f0xx_it.c
    ../: data_structures.c
  group inc
    ../inc/: button.h nixie_hw_masks.h primative_data_struct.h shift_reg.h data_structures.h stm32f0xx_hal_conf.h stm32f0xx_it.h
  group hal
    ../lib/stm32f0xx-hal-lib/src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c
software components: CMSIS:CORE 4.2.0
